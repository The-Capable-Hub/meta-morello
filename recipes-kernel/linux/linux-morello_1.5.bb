require linux-morello.inc

LIC_FILES_CHKSUM  = "file://COPYING;md5=6bc538ed5bd9a7fc9398086aedcd7e46"

SRCREV = "87d06928f90fe910311210a0149d03f3420f593c"

LINUX_VERSION          = "5.18"
LINUX_VERSION_EXTENSION= "-yocto-purecap"

COMPATIBLE_MACHINE = "morello"
