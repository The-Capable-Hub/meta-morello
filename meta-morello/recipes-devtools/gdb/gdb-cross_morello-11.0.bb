require recipes-devtools/gdb/gdb-cross.inc
require gdb.inc
