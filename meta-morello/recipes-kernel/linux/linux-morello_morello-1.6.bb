require linux-morello.inc

LIC_FILES_CHKSUM  = "file://COPYING;md5=6bc538ed5bd9a7fc9398086aedcd7e46"

SRCREV    = "c4b74f2e4712d38f2ea9d5b924f52e38c6faa446"
SRCBRANCH = "morello/master"

LINUX_VERSION          = "6.1"
LINUX_VERSION_EXTENSION= "-yocto-purecap"

COMPATIBLE_MACHINE = "morello"
