require linux-morello.inc

LIC_FILES_CHKSUM  = "file://COPYING;md5=6bc538ed5bd9a7fc9398086aedcd7e46"

SRCREV    = "661ebe4f81e2840e5d706c24c36af63bdbc01b3e"

LINUX_VERSION           = "6.4"
LINUX_VERSION_EXTENSION = "-yocto-purecap"

COMPATIBLE_MACHINE = "morello"

